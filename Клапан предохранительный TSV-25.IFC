Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Клапан предохранительный TSV-25.IFC
Time: 2026-10-09T06:36:50
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Клапан предохранительный TSV-25
In: Default Storey
PredefinedType: ELEMENT; Material: 0
